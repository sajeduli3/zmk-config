## boards/shields/sajedull_3x3/Kconfig.defconfig
```kconfig
if SHIELD_SAJEDULL_3X3

config ZMK_KEYBOARD_NAME
    default "Sajedull 3x3"

endif
```
